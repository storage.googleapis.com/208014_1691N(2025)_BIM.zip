Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 1691N(2025).ifc
Time: 2025-05-20T22:46:07
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcFlowController: 1691N(2025):1691N Shower set, 1691N(2025):1691N Shower set:352005
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 1691N(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1112, EN 1113; ETIM Class Number: EC010109 Sliding rod combination; Noise Class: I (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1691N; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1691N; VVS Number: 737776404
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Connection Size: G1/2; DN Size: Ø 19 mm; Flow Rate At 300kPa: 0.2 dm3/s; Hand Shower Size: Ø 90 mm; Installation Type: Wall mounted; Installation Width: 671 mm; Max. Hot Water Supply: 65 C; Shower Parts: Hand shower;Shower rail;Adjustable shower rail bracket;Shower hose (1500 mm);Anti limescale technology (easy to clean); Shower Spray: Refreshing - Strong water stream, activates and refreshes body; Shower Spray Number: 1 spray function; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 158.309 mm; NominalHeight: 700.25 mm; NominalWidth: 139.616 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/1691N; Catalog Drawing URL: http://static.oras.com/catdrw/1691N; Category B2C: Shower solutions; Dimension Drawing URL: http://static.oras.com/dimdrw/1691N; FDV Document URL: http://www.oras.com/datasheet/1691N/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1691N; Group: Shower set; Installation and Maintenance Guide URL: http://static.oras.com/manual/1691N; Interactive AR View URL: https://static.oras.com/AR/1691N; Long Marketing: Introducing this Oras Linea shower set - a timeless choice for every modern bathroom. With a sleek chrome finish and wall-mounted installation, this shower set not only comes with a universal design but also offers outstanding price-performance ratio. The set includes a hand shower, shower rail, adjustable shower rail bracket, and a shower hose, all featuring anti-scale technology for easy cleaning. The refreshing spray type provides a strong water stream that activates and refreshes the body. With one spray function, this shower set is perfect for those who want a simple yet effective shower experience. Choose the Linea line for daily enjoyment in everyday use.; Manufacturer: Oras; Market: International;Denmark;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1691N; Model: 1691N Shower set; Name_en: 1691N Shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1691N; Product Family: Oras Linea; Product Image URL: http://static.oras.com/image/1691N; Product URL: http://static.oras.com/1691N; Spare-Part Information URL: http://static.oras.com/sp/1691N; Technical DataSheet URL: http://www.oras.com/datasheet/1691N/en; Type Name: 1691N Shower set; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1691N(2025); Features: n/a; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 1691N; Name: 1691N Shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 140x160x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.230725 m2; Volume: 0.0154773 m3
Identity Data - Mark: 14
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1691N(2025); Family and Type: 1691N(2025): 1691N Shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1691N Shower set; Type Id: 351989; WarrantyStartDate: n/a
